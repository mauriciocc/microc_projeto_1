# Keil uVision project projeto.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: projeto +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: projeto.a51
